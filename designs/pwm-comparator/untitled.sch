v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {pwm-comp.sym} 120 -90 0 0 {name=x1}
C {pwm-comp.sym} 130 130 0 0 {name=x2}
C {lab_pin.sym} 200 -310 0 0 {name=p1 sig_type=std_logic lab=xxx}
